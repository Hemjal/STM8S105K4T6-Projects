<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\uart2.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\Project 3 UART with Arduino\uart_arduino_stm8s.ewp</path>
    </project>
    <batchBuild />
</workspace>
