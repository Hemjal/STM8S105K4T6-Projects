<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\i2c_stm8s.ewp</path>
    </project>
    <batchBuild />
</workspace>
