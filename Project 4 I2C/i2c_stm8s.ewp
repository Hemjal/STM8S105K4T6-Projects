# IAR project i2c_stm8s.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105K4 STM8S105K4
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: i2c_stm8s.hex
  ILINK.IlinkOutputFile: i2c_stm8s.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    src/: main.c stm8s.h stm8s_clk.c stm8s_clk.h stm8s_conf.h stm8s_delay.c stm8s_delay.h stm8s_gpio.c stm8s_gpio.h stm8s_i2c.c stm8s_i2c.h stm8s_uart2.c stm8s_uart2.h
